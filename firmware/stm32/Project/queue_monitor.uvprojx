# Keil uVision project queue_monitor.uvprojx, settings and files
target queue_monitor (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: queue_monitor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Start;..\Library;..\App;..\BSP;..\..\core;..\Middlewares\FatFs
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../Start/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
  group Library
    ../Library/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_spi.c
  group Core
    ../../core/: gate_counter.c queue_grade.c protocol.c qsm_history.c
  group App
    ../App/: app_main.c data_logger.c hist_store.c stm32f10x_conf.h
  group BSP
    ../BSP/: bsp_e18.c bsp_uart.c bsp_ds3231.c bsp_sdcard.c bsp_sd_disk.c
  group Middlewares
    ../Middlewares/FatFs/: ff.c diskio.c
